SUMMARY = "WPE Framework Launcher Plugin. Plugin to launch external linux applications and scripts"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

require include/wpeframework-plugins.inc

SRC_URI = "git://git@github.com/WebPlatformForEmbedded/WPEPluginLauncher.git"
SRCREV = "d1c386592f27571307617a9fd77ad69bbd1442aa"

